# BufferUpr model...
MACHINE_MODEL = "apu2"

# ...doesn't match the Yocto machine
COMPATIBLE_MACHINE = "pcengines-apu2"

require serial-number.inc

