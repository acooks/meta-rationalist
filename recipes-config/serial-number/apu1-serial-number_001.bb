# BufferUpr model...
MACHINE_MODEL = "apu1"

# ...doesn't match the Yocto machine
COMPATIBLE_MACHINE = "mousetrap_hw"

require serial-number.inc

